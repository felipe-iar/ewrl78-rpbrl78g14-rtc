<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rtc-test.ewp</path>
    </project>
    <batchBuild />
</workspace>
